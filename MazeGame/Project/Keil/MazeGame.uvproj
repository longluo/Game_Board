# Keil uVision project MazeGame.uvproj, settings and files
target MazeGame (ARM-ADS)
  device: LM3S8962 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: MazeGame +hex
  c flags: Optim=3 oTime=1
  c include: ..\..\Source\App;..\..\Source\Game;..\..\Source\Game\Images;..\..\Source\Game\Sound\Head;..\..\Source\Game\Random;..\..\Source\LM3S_Lib\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../../Source/App/: main.c
  group HAL
    ../../Source/HAL/Oled/Src/: rit128x96x4.c
    ../../Source/HAL/: startup_rvmdk.S
  group Game
    ../../Source/Game/: game.c
  group Sound
    ../../Source/Game/Sound/Src/: audio.c sounds.c
  group Images
    ../../Source/Game/Images/: images.c
  group Random
    ../../Source/Game/Random/: random.c
  group LM3S_Drv_Lib
    ../../Source/LM3S_Lib/DriverLib/: driverlib.lib
